## sound/soc/iphone/Kconfig
```kconfig
config SND_APPLE_IPHONE
	tristate "Audio for the Apple iPhone"
	depends on MACH_APPLE_IPHONE
```
